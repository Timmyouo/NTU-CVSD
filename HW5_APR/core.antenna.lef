

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO core 
  PIN i_clk 
    ANTENNAPARTIALMETALAREA 0.008 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.028 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 37.122 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 130.067 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0556 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 74.3291 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 259.868 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.102596 LAYER VIA45 ;
  END i_clk
  PIN i_rst_n 
    ANTENNAPARTIALMETALAREA 19.353 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 67.8755 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2106 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 92.6963 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 324.629 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.171415 LAYER VIA23 ;
  END i_rst_n
  PIN i_in_valid 
    ANTENNAPARTIALMETALAREA 22.531 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 78.9985 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1586 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 143.969 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 503.902 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.227617 LAYER VIA23 ;
  END i_in_valid
  PIN i_in_data[31] 
    ANTENNAPARTIALMETALAREA 0.212 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.742 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 41.734 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 146.209 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 21.49 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.355 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.195 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 124.236 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 434.719 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.00138 LAYER VIA45 ;
  END i_in_data[31]
  PIN i_in_data[30] 
    ANTENNAPARTIALMETALAREA 20.703 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 72.4605 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 39.078 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 136.913 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.472 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.292 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.195 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 58.3297 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 207.454 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.07848 LAYER VIA45 ;
  END i_in_data[30]
  PIN i_in_data[29] 
    ANTENNAPARTIALMETALAREA 21.061 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 73.7135 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 32.156 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 112.686 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.195 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 183.363 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 642.624 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.816247 LAYER VIA34 ;
  END i_in_data[29]
  PIN i_in_data[28] 
    ANTENNAPARTIALMETALAREA 21.911 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 76.6885 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 30.552 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 107.072 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2106 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 174.649 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 612.401 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA34 ;
  END i_in_data[28]
  PIN i_in_data[27] 
    ANTENNAPARTIALMETALAREA 0.472 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.652 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 11.422 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 40.257 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.195 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 220.89 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 775.137 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA34 ;
  END i_in_data[27]
  PIN i_in_data[26] 
    ANTENNAPARTIALMETALAREA 22.797 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 79.9295 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0572 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 400.856 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 1404.14 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 14.472 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 50.792 LAYER METAL3 ;
    ANTENNAGATEAREA 0.195 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 475.071 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1664.61 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA34 ;
  END i_in_data[26]
  PIN i_in_data[25] 
    ANTENNAPARTIALMETALAREA 19.161 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 67.2035 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0572 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 337.289 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 1181.66 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.978 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.563 LAYER METAL3 ;
    ANTENNAGATEAREA 0.2106 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 341.933 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1198.58 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA34 ;
  END i_in_data[25]
  PIN i_in_data[24] 
    ANTENNAPARTIALMETALAREA 24.115 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 84.5425 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.195 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 143.696 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 496.415 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 1.26224 LAYER VIA23 ;
  END i_in_data[24]
  PIN i_in_data[23] 
    ANTENNAPARTIALMETALAREA 19.38 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 67.97 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.518 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.953 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 32.4314 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 112.878 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.766693 LAYER VIA34 ;
  END i_in_data[23]
  PIN i_in_data[22] 
    ANTENNAPARTIALMETALAREA 18.706 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 65.471 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 268.524 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 938.561 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.91 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.325 LAYER METAL3 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 288.874 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1010.76 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[22]
  PIN i_in_data[21] 
    ANTENNAPARTIALMETALAREA 16.419 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 57.4665 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.922 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.867 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 40.7521 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 141.675 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[21]
  PIN i_in_data[20] 
    ANTENNAPARTIALMETALAREA 16.213 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 56.7455 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.906 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.811 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 21.5993 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 75.9041 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[20]
  PIN i_in_data[19] 
    ANTENNAPARTIALMETALAREA 16.263 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 56.9205 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 21.852 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 76.622 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 161.258 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 565.214 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[19]
  PIN i_in_data[18] 
    ANTENNAPARTIALMETALAREA 16.917 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 59.2095 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 237.658 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 829.46 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.991758 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 24.122 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 84.567 LAYER METAL3 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 406.343 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1420.84 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[18]
  PIN i_in_data[17] 
    ANTENNAPARTIALMETALAREA 19.203 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 67.6305 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 139.568 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 489.083 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.514245 LAYER VIA23 ;
  END i_in_data[17]
  PIN i_in_data[16] 
    ANTENNAPARTIALMETALAREA 15.696 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 54.936 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 30.95 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 108.465 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 232.534 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 814.175 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[16]
  PIN i_in_data[15] 
    ANTENNAPARTIALMETALAREA 16.329 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 57.1515 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 41.854 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 146.769 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 321.694 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1128.61 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[15]
  PIN i_in_data[14] 
    ANTENNAPARTIALMETALAREA 18.82 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 66.29 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 151.835 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 528.281 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.514245 LAYER VIA23 ;
  END i_in_data[14]
  PIN i_in_data[13] 
    ANTENNAPARTIALMETALAREA 22.164 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 77.854 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 164.319 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 573.719 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.514245 LAYER VIA23 ;
  END i_in_data[13]
  PIN i_in_data[12] 
    ANTENNAPARTIALMETALAREA 24.234 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 85.099 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1534 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 159.056 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 558.074 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.470665 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.898 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.783 LAYER METAL3 ;
    ANTENNAGATEAREA 0.2236 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 167.544 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 588.41 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[12]
  PIN i_in_data[11] 
    ANTENNAPARTIALMETALAREA 23.34 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 81.97 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1534 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 154.632 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 542.27 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.470665 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 4.474 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.799 LAYER METAL3 ;
    ANTENNAGATEAREA 0.2236 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 174.641 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 612.927 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[11]
  PIN i_in_data[10] 
    ANTENNAPARTIALMETALAREA 20.986 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 73.591 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 293.551 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 1027.01 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.991758 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 9.064 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.864 LAYER METAL3 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 418.056 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1464.7 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.48764 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.468 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.778 LAYER METAL4 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 424.485 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1489.12 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.98352 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.334 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.309 LAYER METAL5 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 429.073 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1507.1 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 2.4794 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL6 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 431.051 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1515.95 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA67 ;
    ANTENNAMAXCUTCAR 2.97527 LAYER VIA67 ;
    ANTENNAPARTIALMETALAREA 13.112 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 46.452 LAYER METAL7 ;
    ANTENNAGATEAREA 0.143 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 522.743 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 1840.79 LAYER METAL7 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA78 ;
  END i_in_data[10]
  PIN i_in_data[9] 
    ANTENNAPARTIALMETALAREA 14.715 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.5025 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.334 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.309 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.504 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.904 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 149.709 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 528.527 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.98352 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 62.618 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 219.303 LAYER METAL5 ;
    ANTENNAGATEAREA 0.143 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 587.597 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2062.11 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA56 ;
  END i_in_data[9]
  PIN i_in_data[8] 
    ANTENNAPARTIALMETALAREA 0.416 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.456 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 8.512 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.932 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 201.805 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 707.982 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.766693 LAYER VIA34 ;
  END i_in_data[8]
  PIN i_in_data[7] 
    ANTENNAPARTIALMETALAREA 0.118 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.413 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 25.082 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 87.927 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2236 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 196.163 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 687.174 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.675694 LAYER VIA34 ;
  END i_in_data[7]
  PIN i_in_data[6] 
    ANTENNAPARTIALMETALAREA 20.679 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 72.6565 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2236 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 94.5391 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 330.866 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.514245 LAYER VIA23 ;
  END i_in_data[6]
  PIN i_in_data[5] 
    ANTENNAPARTIALMETALAREA 16.667 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.4745 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 239.279 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 835.793 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.991758 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 33.086 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 115.941 LAYER METAL3 ;
    ANTENNAGATEAREA 0.143 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 470.649 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1646.57 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END i_in_data[5]
  PIN i_in_data[4] 
    ANTENNAPARTIALMETALAREA 19.254 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 67.529 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 269.76 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 943.739 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.991758 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.334 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.309 LAYER METAL3 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 274.348 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 961.72 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.48764 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL4 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 276.326 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 970.566 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.98352 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 31.87 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 111.685 LAYER METAL5 ;
    ANTENNAGATEAREA 0.143 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 499.193 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1751.58 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA56 ;
  END i_in_data[4]
  PIN i_in_data[3] 
    ANTENNAPARTIALMETALAREA 14.743 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.6005 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 120.29 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 421.715 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.576 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.296 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 12.2388 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 49.5032 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA56 ;
  END i_in_data[3]
  PIN i_in_data[2] 
    ANTENNAPARTIALMETALAREA 50.254 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 176.029 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 13.834 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.559 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.143 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 123.929 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 435.477 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA45 ;
  END i_in_data[2]
  PIN i_in_data[1] 
    ANTENNAPARTIALMETALAREA 0.318 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.113 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 105.748 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 370.678 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 1.214 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.529 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 65.0508 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 228.126 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 2.4794 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 1.616 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.796 LAYER METAL6 ;
    ANTENNAGATEAREA 0.143 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 76.3515 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 268.658 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 2.57123 LAYER VIA67 ;
  END i_in_data[1]
  PIN i_in_data[0] 
    ANTENNAPARTIALMETALAREA 15.545 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.5475 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 102.382 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 358.897 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.478 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.953 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 14.4615 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 59.0082 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 2.4794 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.304 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.204 LAYER METAL6 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 18.6374 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 75.5467 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA67 ;
    ANTENNAMAXCUTCAR 2.97527 LAYER VIA67 ;
    ANTENNAPARTIALMETALAREA 0.2268 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.77 LAYER METAL7 ;
    ANTENNAGATEAREA 0.0728 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 21.7527 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 86.1236 LAYER METAL7 ;
    ANTENNAPARTIALCUTAREA 0.1296 LAYER VIA78 ;
    ANTENNAMAXCUTCAR 4.75549 LAYER VIA78 ;
    ANTENNAPARTIALMETALAREA 1.7736 LAYER METAL8 ;
    ANTENNAPARTIALMETALSIDEAREA 8.676 LAYER METAL8 ;
    ANTENNAGATEAREA 0.143 LAYER METAL8 ; 
    ANTENNAMAXAREACAR 34.1555 LAYER METAL8 ;
    ANTENNAMAXSIDEAREACAR 146.795 LAYER METAL8 ;
  END i_in_data[0]
  PIN o_in_ready 
    ANTENNAPARTIALMETALAREA 0.876 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.066 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 66.064 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 231.504 LAYER METAL4 ;
  END o_in_ready
  PIN o_out_data1[7] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 32.309 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 113.222 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 480.957 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1686.7 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END o_out_data1[7]
  PIN o_out_data1[6] 
    ANTENNAPARTIALMETALAREA 0.556 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.946 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 59.928 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 209.888 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1267.9 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 4430.73 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA45 ;
  END o_out_data1[6]
  PIN o_out_data1[5] 
    ANTENNAPARTIALMETALAREA 1.178 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.123 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 54.188 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 189.798 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1172.1 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 4101.83 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA45 ;
  END o_out_data1[5]
  PIN o_out_data1[4] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 32.036 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 112.266 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 556.37 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1950.65 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END o_out_data1[4]
  PIN o_out_data1[3] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 34.896 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 122.416 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 509.077 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1787.11 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END o_out_data1[3]
  PIN o_out_data1[2] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 25.946 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 90.951 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 480.104 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1682.19 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END o_out_data1[2]
  PIN o_out_data1[1] 
    ANTENNAPARTIALMETALAREA 0.345 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2075 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 35.102 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 122.997 LAYER METAL4 ;
  END o_out_data1[1]
  PIN o_out_data1[0] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.196 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.826 LAYER METAL3 ;
  END o_out_data1[0]
  PIN o_out_data2[7] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.059 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.4865 LAYER METAL3 ;
  END o_out_data2[7]
  PIN o_out_data2[6] 
    ANTENNAPARTIALMETALAREA 3.791 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4085 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 5.88 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.72 LAYER METAL4 ;
  END o_out_data2[6]
  PIN o_out_data2[5] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.465 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 57.9075 LAYER METAL3 ;
  END o_out_data2[5]
  PIN o_out_data2[4] 
    ANTENNAPARTIALMETALAREA 5.194 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.179 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 5.388 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.998 LAYER METAL4 ;
  END o_out_data2[4]
  PIN o_out_data2[3] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 17.015 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 59.5525 LAYER METAL3 ;
  END o_out_data2[3]
  PIN o_out_data2[2] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.804 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 58.954 LAYER METAL3 ;
  END o_out_data2[2]
  PIN o_out_data2[1] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 26.16 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 91.84 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 391.596 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1375.98 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END o_out_data2[1]
  PIN o_out_data2[0] 
    ANTENNAPARTIALMETALAREA 25.298 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 88.543 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 3.42 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.11 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 114.801 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 407.195 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA45 ;
  END o_out_data2[0]
  PIN o_out_data3[7] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.28 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.98 LAYER METAL3 ;
  END o_out_data3[7]
  PIN o_out_data3[6] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.06 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.21 LAYER METAL3 ;
  END o_out_data3[6]
  PIN o_out_data3[5] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.081 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.2835 LAYER METAL3 ;
  END o_out_data3[5]
  PIN o_out_data3[4] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.041 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.1435 LAYER METAL3 ;
  END o_out_data3[4]
  PIN o_out_data3[3] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.043 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.1505 LAYER METAL3 ;
  END o_out_data3[3]
  PIN o_out_data3[2] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.199 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.6965 LAYER METAL3 ;
  END o_out_data3[2]
  PIN o_out_data3[1] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 23.771 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 83.3385 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 365.457 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1284.49 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END o_out_data3[1]
  PIN o_out_data3[0] 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 25.26 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 88.55 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 395.271 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1386.85 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.02849 LAYER VIA34 ;
  END o_out_data3[0]
  PIN o_out_data4[7] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.224 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.784 LAYER METAL3 ;
  END o_out_data4[7]
  PIN o_out_data4[6] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
  END o_out_data4[6]
  PIN o_out_data4[5] 
    ANTENNAPARTIALMETALAREA 85.502 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 299.257 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.974 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.049 LAYER METAL3 ;
  END o_out_data4[5]
  PIN o_out_data4[4] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 85.127 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 298.084 LAYER METAL2 ;
  END o_out_data4[4]
  PIN o_out_data4[3] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 85.031 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 297.889 LAYER METAL2 ;
  END o_out_data4[3]
  PIN o_out_data4[2] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 84.736 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 296.996 LAYER METAL2 ;
  END o_out_data4[2]
  PIN o_out_data4[1] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 84.533 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 296.145 LAYER METAL2 ;
  END o_out_data4[1]
  PIN o_out_data4[0] 
    ANTENNAPARTIALMETALAREA 14.747 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.6145 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.794 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.919 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.242 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.987 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 65.33 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 228.795 LAYER METAL6 ;
  END o_out_data4[0]
  PIN o_out_addr1[11] 
    ANTENNAPARTIALMETALAREA 14.695 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.4325 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.61 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.275 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.242 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.987 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 63.69 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 223.055 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2314 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 337.007 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1171.74 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 1.51592 LAYER VIA67 ;
  END o_out_addr1[11]
  PIN o_out_addr1[10] 
    ANTENNAPARTIALMETALAREA 14.735 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.5725 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.242 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.987 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.242 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.987 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 63.936 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 223.916 LAYER METAL6 ;
  END o_out_addr1[10]
  PIN o_out_addr1[9] 
    ANTENNAPARTIALMETALAREA 14.774 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.709 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.144 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.644 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.15 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.665 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA56 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 65.33 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 228.795 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2249 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 333.874 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1159.86 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 1.18656 LAYER VIA67 ;
  END o_out_addr1[9]
  PIN o_out_addr1[8] 
    ANTENNAPARTIALMETALAREA 1.305 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5675 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 62.598 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 219.233 LAYER METAL3 ;
  END o_out_addr1[8]
  PIN o_out_addr1[7] 
    ANTENNAPARTIALMETALAREA 0.085 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2975 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 61.838 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 216.713 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2249 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 405.188 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1419.41 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.08899 LAYER VIA34 ;
  END o_out_addr1[7]
  PIN o_out_addr1[6] 
    ANTENNAPARTIALMETALAREA 0.415 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4525 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 55.156 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 193.186 LAYER METAL3 ;
  END o_out_addr1[6]
  PIN o_out_addr1[5] 
    ANTENNAPARTIALMETALAREA 0.713 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4955 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 53.684 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 188.034 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2249 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 335.438 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1170.5 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.24951 LAYER VIA34 ;
  END o_out_addr1[5]
  PIN o_out_addr1[4] 
    ANTENNAPARTIALMETALAREA 1.094 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.829 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.4028 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 52.59 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 184.205 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2184 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 354.05 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1232.3 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.42753 LAYER VIA34 ;
  END o_out_addr1[4]
  PIN o_out_addr1[3] 
    ANTENNADIFFAREA 0.5926 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 21.713 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 76.1355 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2249 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 103.364 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 359.589 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.544495 LAYER VIA23 ;
  END o_out_addr1[3]
  PIN o_out_addr1[2] 
    ANTENNADIFFAREA 0.5926 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.394 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 57.519 LAYER METAL2 ;
  END o_out_addr1[2]
  PIN o_out_addr1[1] 
    ANTENNAPARTIALMETALAREA 14.807 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.8245 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 37.066 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 130.151 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2249 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 169.47 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 594.89 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.08899 LAYER VIA34 ;
  END o_out_addr1[1]
  PIN o_out_addr1[0] 
    ANTENNAPARTIALMETALAREA 18.369 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 64.4315 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.438 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.173 LAYER METAL3 ;
  END o_out_addr1[0]
  PIN o_out_addr2[11] 
    ANTENNAPARTIALMETALAREA 16.133 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 56.6055 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.61 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.275 LAYER METAL3 ;
  END o_out_addr2[11]
  PIN o_out_addr2[10] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.595 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.2225 LAYER METAL2 ;
  END o_out_addr2[10]
  PIN o_out_addr2[9] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 17.487 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 61.3445 LAYER METAL2 ;
  END o_out_addr2[9]
  PIN o_out_addr2[8] 
    ANTENNAPARTIALMETALAREA 16.811 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.9785 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.242 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.987 LAYER METAL3 ;
  END o_out_addr2[8]
  PIN o_out_addr2[7] 
    ANTENNAPARTIALMETALAREA 16.902 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 59.157 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.188 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.798 LAYER METAL3 ;
  END o_out_addr2[7]
  PIN o_out_addr2[6] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.507 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 57.9145 LAYER METAL2 ;
  END o_out_addr2[6]
  PIN o_out_addr2[5] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.673 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.3555 LAYER METAL2 ;
  END o_out_addr2[5]
  PIN o_out_addr2[4] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.714 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.499 LAYER METAL2 ;
  END o_out_addr2[4]
  PIN o_out_addr2[3] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.661 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.3135 LAYER METAL2 ;
  END o_out_addr2[3]
  PIN o_out_addr2[2] 
    ANTENNAPARTIALMETALAREA 0.118 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.413 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.082 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.427 LAYER METAL3 ;
  END o_out_addr2[2]
  PIN o_out_addr2[1] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.707 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.6145 LAYER METAL2 ;
  END o_out_addr2[1]
  PIN o_out_addr2[0] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 16.757 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.7895 LAYER METAL2 ;
  END o_out_addr2[0]
  PIN o_out_addr3[11] 
    ANTENNADIFFAREA 0.1428 LAYER METAL2 ; 
    ANTENNAPARTIALMETALAREA 17.346 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 60.851 LAYER METAL2 ;
  END o_out_addr3[11]
  PIN o_out_addr3[10] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 9.281 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.6235 LAYER METAL3 ;
  END o_out_addr3[10]
  PIN o_out_addr3[9] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.216 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.756 LAYER METAL3 ;
  END o_out_addr3[9]
  PIN o_out_addr3[8] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.053 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1855 LAYER METAL3 ;
  END o_out_addr3[8]
  PIN o_out_addr3[7] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.185 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.7875 LAYER METAL3 ;
  END o_out_addr3[7]
  PIN o_out_addr3[6] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 16.334 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 57.169 LAYER METAL3 ;
  END o_out_addr3[6]
  PIN o_out_addr3[5] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.864 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.024 LAYER METAL3 ;
  END o_out_addr3[5]
  PIN o_out_addr3[4] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.419 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.9665 LAYER METAL3 ;
  END o_out_addr3[4]
  PIN o_out_addr3[3] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.019 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0665 LAYER METAL3 ;
  END o_out_addr3[3]
  PIN o_out_addr3[2] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.992 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.472 LAYER METAL3 ;
  END o_out_addr3[2]
  PIN o_out_addr3[1] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.732 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.562 LAYER METAL3 ;
  END o_out_addr3[1]
  PIN o_out_addr3[0] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.913 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.1955 LAYER METAL3 ;
  END o_out_addr3[0]
  PIN o_out_addr4[11] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.575 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.0125 LAYER METAL3 ;
  END o_out_addr4[11]
  PIN o_out_addr4[10] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.778 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.223 LAYER METAL3 ;
  END o_out_addr4[10]
  PIN o_out_addr4[9] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.578 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.023 LAYER METAL3 ;
  END o_out_addr4[9]
  PIN o_out_addr4[8] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.781 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.7335 LAYER METAL3 ;
  END o_out_addr4[8]
  PIN o_out_addr4[7] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.777 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.2195 LAYER METAL3 ;
  END o_out_addr4[7]
  PIN o_out_addr4[6] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.624 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.184 LAYER METAL3 ;
  END o_out_addr4[6]
  PIN o_out_addr4[5] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.504 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.264 LAYER METAL3 ;
  END o_out_addr4[5]
  PIN o_out_addr4[4] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 14.573 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.0055 LAYER METAL3 ;
  END o_out_addr4[4]
  PIN o_out_addr4[3] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.691 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.9185 LAYER METAL3 ;
  END o_out_addr4[3]
  PIN o_out_addr4[2] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.826 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.391 LAYER METAL3 ;
  END o_out_addr4[2]
  PIN o_out_addr4[1] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.418 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.963 LAYER METAL3 ;
  END o_out_addr4[1]
  PIN o_out_addr4[0] 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 15.829 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.4015 LAYER METAL3 ;
  END o_out_addr4[0]
  PIN o_out_valid1 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 102.749 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 359.761 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3172 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 325.141 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1138.5 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.227617 LAYER VIA34 ;
  END o_out_valid1
  PIN o_out_valid2 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.516 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.086 LAYER METAL3 ;
  END o_out_valid2
  PIN o_out_valid3 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.444 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.694 LAYER METAL3 ;
  END o_out_valid3
  PIN o_out_valid4 
    ANTENNADIFFAREA 0.1428 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.089 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3115 LAYER METAL3 ;
  END o_out_valid4
  PIN o_exe_finish 
    ANTENNADIFFAREA 0.5926 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.127 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9445 LAYER METAL3 ;
  END o_exe_finish
END core

END LIBRARY
